DTB_SUBDIR="dts/"

KERNEL_DEVICETREE = "socfpga_cyclone5_socdk socfpga_arria5_socdk socfpga_vt socfpga_arria10_socdk_sdmmc socfpga_arria10_socdk_qspi"

require recipes-kernel/linux/linux-altera-latest.inc

