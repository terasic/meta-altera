FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://full-busybox-1.22.cfg"
